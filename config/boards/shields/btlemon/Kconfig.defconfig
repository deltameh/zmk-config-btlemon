## config/boards/shields/btlemon/Kconfig.defconfig
```kconfig
if SHIELD_BTLEMON
           
config ZMK_KEYBOARD_NAME
    default "btlemon"

endif
```
